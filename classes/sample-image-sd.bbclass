# This class file is the legacy way of enabling features.
# Do not use for new features.
SAMPLE_FEATURES_ENABLE_append = " sample-image-sd"
