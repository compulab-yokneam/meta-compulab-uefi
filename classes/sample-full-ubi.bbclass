# Class for those who want to enable all Sample required features for UBI based
# devices.

SAMPLE_FEATURES_ENABLE_append = " \
    sample-image \
    sample-image-ubi \
    sample-client-install \
    sample-systemd \
    sample-ubi \
    sample-uboot \
"
